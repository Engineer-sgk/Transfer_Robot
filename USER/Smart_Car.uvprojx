# Keil uVision project Smart_Car.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Smart_Car
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\MyDrivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../MyDrivers/: MyDrivers.h Global_Variable.c
    ./: main.c delay.c MyInterrupt.c timer.c README.txt
  group MyDrivers
    ../MyDrivers/: MyInit.c System.c BSP_LED.c Key.c BSP_Motor.c PID.c Car_Action.c Tracking.c BSP_Usart.c BSP_TFTDisplay.c BSP_QrScan.c Servo_UART_Config.c Servo_Serail.c Servo_Data_Analysic.c Servo_USER_API.c Filter.c BSP_Color_Scan.c Debug_WiFi.c Robot_Arm.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
